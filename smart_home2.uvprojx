# Keil uVision project smart_home2.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_home2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\hardware\dht11;.\hardware\LCD\24Cxx;.\hardware\LCD\tftlcd;.\hardware\LCD\touch;.\hardware\LSENS;.\public;.\user;.\Json;.\lib\CMSIS;.\lib\STM32F10x_StdPeriph_Driver\inc;.\hardware\esp8266;.\hardware\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./lib/CMSIS/: core_cm3.c system_stm32f10x.c
  group start_up
    ./lib/CMSIS/: startup_stm32f10x_hd.s
  group hardware
    ./hardware/dht11/: dht11.c
    ./hardware/LCD/tftlcd/: tftlcd.c
    ./hardware/LSENS/: lsens.c
    ./hardware/esp8266/: wifi_config.c wifi_function.c
    ./hardware/beep/: beep.c
  group public
    ./public/: led.c system.c SysTick.c usart.c timer.c
    ./Json/: cJSON.c
